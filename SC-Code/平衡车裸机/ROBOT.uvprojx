# Keil uVision project ROBOT.uvprojx, settings and files
target ROBOT (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ROBOT +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\USR\ENCODER;.\USR\KEY;.\USR\LED;.\USR\MOTO;.\USR\MPU6050;.\USR\MPU6050\eMPL;.\USR\PBDATA;.\USR\PID;.\USR\PWM;.\USR\TIME;.\USR\MAIN;.\USR\SYS;.\USR\DEBUG;.\USR\ADC;.\USR\BLUETOOTH;.\USR\VOICE;.\USR\FLASH;.\USR\MPU_INT;.\USR\WATCH_DOG;.\USR\UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/MAIN/: main.c
    ./USR/ENCODER/: encoder.c
    ./USR/KEY/: key.c
    ./USR/LED/: led.c
    ./USR/MOTO/: moto.c
    ./USR/MPU6050/: mpu6050.c mpuiic.c
    ./USR/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./USR/PBDATA/: pbdata.c
    ./USR/PID/: pid.c
    ./USR/PWM/: pwm.c
    ./USR/TIME/: time.c
    ./USR/SYS/: sys.c
    ./USR/DEBUG/: debug.c
    ./USR/ADC/: adc.c
    ./USR/BLUETOOTH/: bluetooth.c
    ./USR/VOICE/: voice.c
    ./USR/FLASH/: flash_data.c
    ./USR/MPU_INT/: mpu_int.c
    ./USR/WATCH_DOG/: watch_dog.c
    ./USR/UI/: ui.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
