# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\PBDATA;..\HARDWARE\MY_TASK;..\HARDWARE\KEY;..\HARDWARE\TIME;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ENCODER;..\HARDWARE\MOTO;..\HARDWARE\PWM;..\HARDWARE\PID;..\HARDWARE\DEBUG;..\HARDWARE\ADC;..\HARDWARE\BLUETOOTH;..\HARDWARE\VOICE;..\HARDWARE\FLASH;..\HARDWARE\WATCH_DOG;..\HARDWARE\UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PBDATA/: pbdata.c
    ../HARDWARE/MY_TASK/: my_task.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MOTO/: moto.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/DEBUG/: debug.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/VOICE/: voice.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/FLASH/: flash_data.c
    ../HARDWARE/WATCH_DOG/: watch_dog.c
    ../HARDWARE/UI/: ui.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_iwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
